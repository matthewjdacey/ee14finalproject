# Keil uVision project gyrotest.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: gyrotest +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    C:/Users/phenne04/Downloads/tmdarwen STM32 master STM32F411-OnboardGyroAccel/: StringUtilities.c
    ../Lab2 GPIO/: core_cm4_constants.s startup_stm32l476xx.s stm32l476xx_constants.s
    ./: main.c gyro.c gyro.h SysTick.c SysTick.h UART.c SysClock.c SysClock.h
    ../Lab2 UART/: UART.h
software components: CMSIS:CORE 5.5.0
